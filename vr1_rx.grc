<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>vr1_rx</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Single</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>OFDM Single</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>amplitude</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>label</key><value>amplitude</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>amplitude</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>option</key><value>"txamplitude"</value></param>
<param><key>section</key><value>"rx"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>length_tag_key</value></param>
<param><key>value</key><value>"frame_len"</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>maxnoutput</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>100</value></param>
<param><key>option</key><value>"maxnoutput"</value></param>
<param><key>section</key><value>"global"</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>occupied_carriers</value></param>
<param><key>value</key><value>(sorted(tuple(set([x for x in range(-56,57)]) - set(pilot_carriers[0]) - set([0,]))),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_length_tag_key</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pattern1</value></param>
<param><key>value</key><value>[0., 1.41421356, 0., -1.41421356]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pattern2</value></param>
<param><key>value</key><value>[1, -1, 1, -1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_carriers</value></param>
<param><key>value</key><value>((-42, -14, -7, 7, 14, 42),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_symbols</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>((1, 1, 1, -1, -1, 1, 1, 1, -1, 1),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_symbols</value></param>
<param><key>value</key><value>((-1,1, 1, -1, -1, -1),)</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rxfreq</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>4.4e9</value></param>
<param><key>option</key><value>"rxfreq1"</value></param>
<param><key>section</key><value>"usrp_hydra"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rxgain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>rxgain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rxgain</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>option</key><value>"rxgain"</value></param>
<param><key>section</key><value>"rx"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>samprate</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>4e6</value></param>
<param><key>option</key><value>"samprate1"</value></param>
<param><key>section</key><value>"usrp_hydra"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word1</value></param>
<param><key>value</key><value>[0., 0., 0., 0., 0., 0.,] + pattern1 * ((fft_len-12)/len(pattern1))  +[0., 0., 0., 0., 0., 0.,] </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word2</value></param>
<param><key>value</key><value>[0., 0., 0., 0., 0., 0.,] + pattern2 * ((fft_len-12)/len(pattern2))  +[0., 0., 0., 0., 0., 0.,] </value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>timeout</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>100</value></param>
<param><key>option</key><value>"zmqtimeout"</value></param>
<param><key>section</key><value>"global"</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>txfreq</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>4.4e9</value></param>
<param><key>option</key><value>"txfreq1"</value></param>
<param><key>section</key><value>"usrp_hydra"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>txgain</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label</key><value>txgain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>txgain</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>option</key><value>"txgain"</value></param>
<param><key>section</key><value>"rx"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>txoutport</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>"2666"</value></param>
<param><key>option</key><value>"txoutport"</value></param>
<param><key>section</key><value>"usrp"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>usrpip</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>"127.0.0.1"</value></param>
<param><key>option</key><value>"ip"</value></param>
<param><key>section</key><value>"usrp"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>amplitude</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>100</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>name</key><value>Tx'd Packets</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>affinity</key><value>1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_tuntap_pdu</key>
<param><key>id</key><value>blocks_tuntap_pdu_0</value></param>
<param><key>istunflag</key><value>False</value></param>
<param><key>ifn</key><value>tap0</value></param>
<param><key>mtu</key><value>10000</value></param>
</block>
<block>
<key>digital_burst_shaper_xx</key>
<param><key>id</key><value>digital_burst_shaper_xx_0</value></param>
<param><key>insert_phasing</key><value>False</value></param>
<param><key>length_tag_name</key><value>"packet_len"</value></param>
<param><key>post_padding</key><value>100</value></param>
<param><key>pre_padding</key><value>2000</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>window</key><value>([])</value></param>
</block>
<block>
<key>digital_ofdm_rx</key>
<param><key>id</key><value>digital_ofdm_rx_0</value></param>
<param><key>cp_len</key><value>16</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
<param><key>packet_len_key</key><value>"packet_len"</value></param>
<param><key>payload_mod</key><value>"BPSK"</value></param>
<param><key>pilot_carriers</key><value>pilot_carriers</value></param>
<param><key>pilot_symbols</key><value>pilot_symbols</value></param>
<param><key>sync_word1</key><value>sync_word1</value></param>
<param><key>sync_word2</key><value>sync_word2</value></param>
</block>
<block>
<key>digital_ofdm_tx</key>
<param><key>id</key><value>digital_ofdm_tx_0</value></param>
<param><key>cp_len</key><value>16</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>packet_len_key</key><value>"packet_len"</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
<param><key>payload_mod</key><value>"BPSK"</value></param>
<param><key>pilot_carriers</key><value>pilot_carriers</value></param>
<param><key>pilot_symbols</key><value>pilot_symbols</value></param>
<param><key>rolloff</key><value>0</value></param>
<param><key>sync_word1</key><value>sync_word1</value></param>
<param><key>sync_word2</key><value>sync_word2</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from gnuradio.digital.utils import tagged_streams</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>100</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>samprate</value></param>
<param><key>center_freq0</key><value>rxfreq</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>txgain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samprate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>txfreq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>rxgain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samprate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>digital_burst_shaper_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tag_debug_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>digital_ofdm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tag_debug_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>digital_ofdm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_tuntap_pdu_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_tuntap_pdu_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>digital_burst_shaper_xx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_tx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>digital_ofdm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
