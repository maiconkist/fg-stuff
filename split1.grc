<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>split1</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Split1</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>Split 1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hdr_format</value></param>
<param><key>value</key><value>digital.header_format_ofdm(occupied_carriers, 1, "packet_len",)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>header_mod</value></param>
<param><key>value</key><value>digital.constellation_bpsk()</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>headerport</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>"2100"</value></param>
<param><key>option</key><value>"headerport"</value></param>
<param><key>section</key><value>"split1"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>ip</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>"127.0.0.1"</value></param>
<param><key>option</key><value>"ip"</value></param>
<param><key>section</key><value>"split1"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>maxnoutput</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>100</value></param>
<param><key>option</key><value>"maxnoutput"</value></param>
<param><key>section</key><value>"global"</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>occupied_carriers</value></param>
<param><key>value</key><value>(range(-26, -21) + range(-20, -7) + range(-6, 0) + range(1, 7) + range(8, 21) + range(22, 27),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_mod</value></param>
<param><key>value</key><value>digital.constellation_bpsk()</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>payloadport</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>"2101"</value></param>
<param><key>option</key><value>"payloadport"</value></param>
<param><key>section</key><value>"split1"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_carriers</value></param>
<param><key>value</key><value>((-21, -7, 7, 21,),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_symbols</value></param>
<param><key>value</key><value>((1, 1, 1, -1,),)</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>rate0</value></param>
<param><key>block_id</key><value>probe1_0</value></param>
<param><key>function_name</key><value>rate</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>rate1</value></param>
<param><key>block_id</key><value>probe1_1</value></param>
<param><key>function_name</key><value>rate</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word1</value></param>
<param><key>value</key><value>[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word2</value></param>
<param><key>value</key><value>[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] </value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>throttle</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>int(100e3)</value></param>
<param><key>option</key><value>"throttle"</value></param>
<param><key>section</key><value>"split1"</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>timeout</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>100</value></param>
<param><key>option</key><value>"zmqtimeout"</value></param>
<param><key>section</key><value>"global"</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>usrpip</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>"127.0.0.1"</value></param>
<param><key>option</key><value>"ip"</value></param>
<param><key>section</key><value>"usrp"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>usrpport</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>"2101"</value></param>
<param><key>option</key><value>"rxoutport"</value></param>
<param><key>section</key><value>"usrp"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>xmlrpcport</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>8080</value></param>
<param><key>option</key><value>"xmlrpcport"</value></param>
<param><key>section</key><value>"split1"</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>payload_mod.bits_per_symbol()</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>90</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>name</key><value>Rx'd Packets</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>50e3</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tuntap_pdu</key>
<param><key>id</key><value>blocks_tuntap_pdu_1</value></param>
<param><key>istunflag</key><value>False</value></param>
<param><key>ifn</key><value>tap0</value></param>
<param><key>mtu</key><value>10000</value></param>
</block>
<block>
<key>digital_crc32_bb</key>
<param><key>id</key><value>digital_crc32_bb_0</value></param>
<param><key>lengthtagname</key><value>"packet_len"</value></param>
<param><key>check</key><value>False</value></param>
<param><key>packed</key><value>True</value></param>
</block>
<block>
<key>digital_ofdm_rx</key>
<param><key>id</key><value>digital_ofdm_rx_0</value></param>
<param><key>cp_len</key><value>fft_len/4</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
<param><key>packet_len_key</key><value>packet_len</value></param>
<param><key>payload_mod</key><value>"BPSK"</value></param>
<param><key>pilot_carriers</key><value>pilot_carriers</value></param>
<param><key>pilot_symbols</key><value>pilot_symbols</value></param>
<param><key>sync_word1</key><value>sync_word1</value></param>
<param><key>sync_word2</key><value>sync_word2</value></param>
</block>
<block>
<key>digital_protocol_formatter_bb</key>
<param><key>id</key><value>digital_protocol_formatter_bb_0</value></param>
<param><key>format</key><value>hdr_format</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>header_bits</value></param>
<param><key>stream_id</key><value>Header Bits</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>probe1_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>mintime</key><value>500.0</value></param>
<param><key>alpha</key><value>0.15</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>probe1_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>mintime</key><value>500.0</value></param>
<param><key>alpha</key><value>0.15</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>Payload Bits</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>Header Bits</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>Payload Bits</value></param>
</block>
<block>
<key>xmlrpc_server</key>
<param><key>id</key><value>xmlrpc_server_0</value></param>
<param><key>addr</key><value>ip</value></param>
<param><key>port</key><value>xmlrpcport</value></param>
</block>
<block>
<key>zeromq_pull_source</key>
<param><key>id</key><value>zeromq_pull_source_0</value></param>
<param><key>address</key><value>"tcp://" + usrpip + ":" + usrpport</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_push_sink</key>
<param><key>id</key><value>zeromq_push_sink_0</value></param>
<param><key>address</key><value>"tcp://" + ip + ":" + headerport</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>timeout</value></param>
</block>
<block>
<key>zeromq_push_sink</key>
<param><key>id</key><value>zeromq_push_sink_1</value></param>
<param><key>address</key><value>"tcp://" + ip + ":" + payloadport</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>timeout</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>digital_crc32_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>probe1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0</source_block_id><sink_block_id>header_bits</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0</source_block_id><sink_block_id>probe1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_tuntap_pdu_1</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>digital_crc32_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tuntap_pdu_1</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>digital_crc32_bb_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_bb_0</source_block_id><sink_block_id>digital_protocol_formatter_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_protocol_formatter_bb_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>zeromq_push_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>zeromq_push_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_0</source_block_id><sink_block_id>digital_ofdm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
