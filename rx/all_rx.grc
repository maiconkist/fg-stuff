<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>all_rx</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Single</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>OFDM Single</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>amp1</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>label</key><value>amp1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>maxnoutput</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>100</value></param>
<param><key>option</key><value>"maxnoutput"</value></param>
<param><key>section</key><value>"global"</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>rate</value></param>
<param><key>block_id</key><value>probe1_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>function_name</key><value>rate</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>samprate1</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>option</key><value>"samprate1"</value></param>
<param><key>section</key><value>"usrp_hydra"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>samprate2</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>option</key><value>"samprate2"</value></param>
<param><key>section</key><value>"usrp_hydra"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>timeout</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>100</value></param>
<param><key>option</key><value>"zmqtimeout"</value></param>
<param><key>section</key><value>"global"</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>txfreq1</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>950e6</value></param>
<param><key>option</key><value>"txfreq1"</value></param>
<param><key>section</key><value>"usrp_hydra"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>txfreq2</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>950e6</value></param>
<param><key>option</key><value>"txfreq2"</value></param>
<param><key>section</key><value>"usrp_hydra"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>txoutport</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>"2666"</value></param>
<param><key>option</key><value>"txoutport"</value></param>
<param><key>section</key><value>"usrp"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>usrp_f</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>4e6</value></param>
<param><key>option</key><value>"txfreq"</value></param>
<param><key>section</key><value>"usrp_hydra"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>usrp_s</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>4e6</value></param>
<param><key>option</key><value>"samprate"</value></param>
<param><key>section</key><value>"usrp_hydra"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>usrpip</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>"127.0.0.1"</value></param>
<param><key>option</key><value>"ip"</value></param>
<param><key>section</key><value>"usrp"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vr1_oc</value></param>
<param><key>value</key><value>(sorted(tuple(set([x for x in range(-26,27)]) - set(vr1_pc[0]) - set([0,]))),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vr1_pattern1</value></param>
<param><key>value</key><value>[0., 1.41421356, 0., -1.41421356]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vr1_pattern2</value></param>
<param><key>value</key><value>[1, -1, 1, -1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vr1_pc</value></param>
<param><key>value</key><value>((-27, -14, -7, 7, 14, 27),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vr1_ps</value></param>
<param><key>value</key><value>((-1,1, 1, -1, -1, -1),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vr1_sw1</value></param>
<param><key>value</key><value>[0., 0., 0., 0., 0., 0.,] + vr1_pattern1 * ((fft_len-12)/len(vr1_pattern1))  +[0., 0., 0., 0., 0., 0.,] </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vr1_sw2</value></param>
<param><key>value</key><value>[0., 0., 0., 0., 0., 0.,] + vr1_pattern2 * ((fft_len-12)/len(vr1_pattern2))  +[0., 0., 0., 0., 0., 0.,] </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vr2_oc</value></param>
<param><key>value</key><value>(sorted(tuple(set([x for x in range(-26,27)]) - set(vr2_pc[0]) - set([0,]))),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vr2_pattern1</value></param>
<param><key>value</key><value>[0., 1.41421356, 0., -1.41421356]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vr2_pattern2</value></param>
<param><key>value</key><value>[1, -1, 1, -1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vr2_pc</value></param>
<param><key>value</key><value>((-14, -7, 7, 14),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vr2_ps</value></param>
<param><key>value</key><value>((1, 1, -1, -1),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vr2_sw1</value></param>
<param><key>value</key><value>[0., 0., 0., 0., 0., 0.,] + vr2_pattern1 * ((fft_len-12)/len(vr2_pattern1))  +[0., 0., 0., 0., 0., 0.,] </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vr2_sw2</value></param>
<param><key>value</key><value>[0., 0., 0., 0., 0., 0.,] + vr2_pattern2 * ((fft_len-12)/len(vr2_pattern2))  + [0., 0., 0., 0., 0., 0.,] </value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>xmlrpcport</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>"xmlrpcport"</value></param>
<param><key>section</key><value>"vr1_tx"</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>amp1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_set</key>
<param><key>id</key><value>blocks_pdu_set_0</value></param>
<param><key>k</key><value>pmt.intern("vr1rx")</value></param>
<param><key>v</key><value>pmt.intern("generate")</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>"vr1tx"</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>100</value></param>
<param><key>minsize</key><value>50</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len_tag_key</key><value>"vr1tx"</value></param>
<param><key>packet_len</key><value>100</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>"vr1rx"</value></param>
</block>
<block>
<key>digital_burst_shaper_xx</key>
<param><key>id</key><value>digital_burst_shaper_xx_0</value></param>
<param><key>insert_phasing</key><value>False</value></param>
<param><key>length_tag_name</key><value>"vr1tx"</value></param>
<param><key>post_padding</key><value>2000</value></param>
<param><key>pre_padding</key><value>2000</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>window</key><value>([])</value></param>
</block>
<block>
<key>digital_ofdm_rx</key>
<param><key>id</key><value>digital_ofdm_rx_0</value></param>
<param><key>cp_len</key><value>16</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>occupied_carriers</key><value>vr1_oc</value></param>
<param><key>packet_len_key</key><value>"vr1rx"</value></param>
<param><key>payload_mod</key><value>"BPSK"</value></param>
<param><key>pilot_carriers</key><value>vr1_pc</value></param>
<param><key>pilot_symbols</key><value>vr1_ps</value></param>
<param><key>sync_word1</key><value>vr1_sw1</value></param>
<param><key>sync_word2</key><value>vr1_sw2</value></param>
</block>
<block>
<key>digital_ofdm_rx</key>
<param><key>id</key><value>digital_ofdm_rx_1</value></param>
<param><key>cp_len</key><value>16</value></param>
<param><key>fft_len</key><value>64</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>occupied_carriers</key><value>vr2_oc</value></param>
<param><key>packet_len_key</key><value>"vr2"</value></param>
<param><key>payload_mod</key><value>"BPSK"</value></param>
<param><key>pilot_carriers</key><value>vr2_pc</value></param>
<param><key>pilot_symbols</key><value>vr2_ps</value></param>
<param><key>sync_word1</key><value>vr2_sw1</value></param>
<param><key>sync_word2</key><value>vr2_sw2</value></param>
</block>
<block>
<key>digital_ofdm_tx</key>
<param><key>id</key><value>digital_ofdm_tx_0</value></param>
<param><key>cp_len</key><value>16</value></param>
<param><key>fft_len</key><value>64</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>packet_len_key</key><value>"vr1tx"</value></param>
<param><key>occupied_carriers</key><value>vr1_oc</value></param>
<param><key>payload_mod</key><value>"BPSK"</value></param>
<param><key>pilot_carriers</key><value>vr1_pc</value></param>
<param><key>pilot_symbols</key><value>vr1_ps</value></param>
<param><key>rolloff</key><value>0</value></param>
<param><key>sync_word1</key><value>vr1_sw1</value></param>
<param><key>sync_word2</key><value>vr1_sw2</value></param>
</block>
<block>
<key>hydra_hydra_source</key>
<param><key>id</key><value>hydra_hydra_source_0</value></param>
<param><key>bandwidth</key><value>usrp_s</value></param>
<param><key>central_frequency</key><value>usrp_f</value></param>
<param><key>fft_m_size</key><value>512</value></param>
<param><key>center_freq1</key><value>txfreq1</value></param>
<param><key>center_freq10</key><value></value></param>
<param><key>center_freq11</key><value></value></param>
<param><key>center_freq12</key><value></value></param>
<param><key>center_freq13</key><value></value></param>
<param><key>center_freq14</key><value></value></param>
<param><key>center_freq15</key><value></value></param>
<param><key>center_freq16</key><value></value></param>
<param><key>center_freq17</key><value></value></param>
<param><key>center_freq18</key><value></value></param>
<param><key>center_freq19</key><value></value></param>
<param><key>center_freq2</key><value>txfreq2</value></param>
<param><key>center_freq20</key><value></value></param>
<param><key>center_freq21</key><value></value></param>
<param><key>center_freq22</key><value></value></param>
<param><key>center_freq23</key><value></value></param>
<param><key>center_freq24</key><value></value></param>
<param><key>center_freq25</key><value></value></param>
<param><key>center_freq26</key><value></value></param>
<param><key>center_freq27</key><value></value></param>
<param><key>center_freq28</key><value></value></param>
<param><key>center_freq29</key><value></value></param>
<param><key>center_freq3</key><value>usrp_f</value></param>
<param><key>center_freq30</key><value></value></param>
<param><key>center_freq4</key><value></value></param>
<param><key>center_freq5</key><value></value></param>
<param><key>center_freq6</key><value></value></param>
<param><key>center_freq7</key><value></value></param>
<param><key>center_freq8</key><value></value></param>
<param><key>center_freq9</key><value></value></param>
<param><key>num_outputs</key><value>2</value></param>
<param><key>samprate1</key><value>samprate1</value></param>
<param><key>samprate10</key><value></value></param>
<param><key>samprate11</key><value></value></param>
<param><key>samprate12</key><value></value></param>
<param><key>samprate13</key><value></value></param>
<param><key>samprate14</key><value></value></param>
<param><key>samprate15</key><value></value></param>
<param><key>samprate16</key><value></value></param>
<param><key>samprate17</key><value></value></param>
<param><key>samprate18</key><value></value></param>
<param><key>samprate19</key><value></value></param>
<param><key>samprate2</key><value>samprate2</value></param>
<param><key>samprate20</key><value></value></param>
<param><key>samprate21</key><value></value></param>
<param><key>samprate22</key><value></value></param>
<param><key>samprate23</key><value></value></param>
<param><key>samprate24</key><value></value></param>
<param><key>samprate25</key><value></value></param>
<param><key>samprate26</key><value></value></param>
<param><key>samprate27</key><value></value></param>
<param><key>samprate28</key><value></value></param>
<param><key>samprate29</key><value></value></param>
<param><key>samprate3</key><value>10e3</value></param>
<param><key>samprate30</key><value></value></param>
<param><key>samprate4</key><value></value></param>
<param><key>samprate5</key><value></value></param>
<param><key>samprate6</key><value></value></param>
<param><key>samprate7</key><value></value></param>
<param><key>samprate8</key><value></value></param>
<param><key>samprate9</key><value></value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>probe1_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>mintime</key><value>500.0</value></param>
<param><key>alpha</key><value>0.15</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>100</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>512</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_RECTANGULAR</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>txfreq1 + 4e6</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>1.0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samprate1</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>usrp_f</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>usrp_s</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>vr1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>vr2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>vr1</value></param>
<param><key>stream_id</key><value>vr1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>vr1_0</value></param>
<param><key>stream_id</key><value>vr2</value></param>
</block>
<block>
<key>xmlrpc_server</key>
<param><key>id</key><value>xmlrpc_server_0</value></param>
<param><key>addr</key><value>192.168.10.30</value></param>
<param><key>port</key><value>xmlrpcport</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>digital_burst_shaper_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_set_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>pdus</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tag_debug_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>digital_ofdm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tag_debug_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>digital_ofdm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_pdu_set_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>digital_burst_shaper_xx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_0</source_block_id><sink_block_id>probe1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_rx_1</source_block_id><sink_block_id>blocks_tag_debug_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_tx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hydra_hydra_source_0</source_block_id><sink_block_id>vr1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hydra_hydra_source_0</source_block_id><sink_block_id>vr1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>hydra_hydra_source_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>digital_ofdm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>digital_ofdm_rx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
