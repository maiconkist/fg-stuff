<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrp</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>USRP</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>usrp</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>amplitude</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>amplitude</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>amplitude</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>amplitude</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>1.0</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>amplitude</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>option</key><value>"txamplitude"</value></param>
<param><key>section</key><value>"usrp"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>amplitude</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>option</key><value>"amplitude1"</value></param>
<param><key>section</key><value>"usrp"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>finalsplitip</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>"192.168.10.23"</value></param>
<param><key>option</key><value>"finalsplitip"</value></param>
<param><key>section</key><value>"usrp"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>finalsplitport</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>"2300"</value></param>
<param><key>option</key><value>"finalsplitport"</value></param>
<param><key>section</key><value>"usrp"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>ip</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>"192.168.10.104"</value></param>
<param><key>option</key><value>"ip"</value></param>
<param><key>section</key><value>"usrp"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>maxnoutput</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>100</value></param>
<param><key>option</key><value>"maxnoutput"</value></param>
<param><key>section</key><value>"global"</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rxfreq</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>4.4e9</value></param>
<param><key>option</key><value>"rxfreq1"</value></param>
<param><key>section</key><value>"usrp"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rxgain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>rxgain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rxgain</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>0.9</value></param>
<param><key>option</key><value>"rxgain"</value></param>
<param><key>section</key><value>"usrp"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rxip</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>"127.0.0.1"</value></param>
<param><key>option</key><value>"ip"</value></param>
<param><key>section</key><value>"rx"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rxoutport</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>"2666"</value></param>
<param><key>option</key><value>"rxoutport"</value></param>
<param><key>section</key><value>"usrp"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>rxport</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>"2300"</value></param>
<param><key>option</key><value>"port"</value></param>
<param><key>section</key><value>"rx"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>rxrate</value></param>
<param><key>block_id</key><value>zrxrate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>function_name</key><value>rate</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>samprate</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>500e3</value></param>
<param><key>option</key><value>"samprate1"</value></param>
<param><key>section</key><value>"usrp"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>timeout</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>100</value></param>
<param><key>option</key><value>"zmqtimeout"</value></param>
<param><key>section</key><value>"global"</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>txfreq</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>949.45e6</value></param>
<param><key>option</key><value>"txfreq1"</value></param>
<param><key>section</key><value>"usrp"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>txgain</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>txgain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>txgain</value></param>
<param><key>value</key><value>0.9</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>txtain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>1.0</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>txgain</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>0.9</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>option</key><value>"txgain"</value></param>
<param><key>section</key><value>"usrp"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>txgain</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>0.9</value></param>
<param><key>option</key><value>"txgain"</value></param>
<param><key>section</key><value>"usrp"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>txoutport</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>"2666"</value></param>
<param><key>option</key><value>"txoutport"</value></param>
<param><key>section</key><value>"usrp"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>txrate</value></param>
<param><key>block_id</key><value>ztxrate</value></param>
<param><key>function_name</key><value>rate</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>xmlrpcport</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>8081</value></param>
<param><key>option</key><value>xmlrpcport</value></param>
<param><key>section</key><value>"usrp"</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>amplitude</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>Tx'd Packet</value></param>
</block>
<block>
<key>digital_burst_shaper_xx</key>
<param><key>id</key><value>digital_burst_shaper_xx_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>insert_phasing</key><value>False</value></param>
<param><key>length_tag_name</key><value>"packet_len"</value></param>
<param><key>post_padding</key><value>100</value></param>
<param><key>pre_padding</key><value>2000</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>window</key><value>([])</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samprate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_1</value></param>
<param><key>bw</key><value>samprate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>samprate</value></param>
<param><key>center_freq0</key><value>txfreq</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>txgain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samprate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>samprate</value></param>
<param><key>center_freq0</key><value>rxfreq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>rxgain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samprate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>xmlrpc_server</key>
<param><key>id</key><value>xmlrpc_server_0_0</value></param>
<param><key>addr</key><value>ip</value></param>
<param><key>port</key><value>xmlrpcport</value></param>
</block>
<block>
<key>zeromq_pull_source</key>
<param><key>id</key><value>zeromq_pull_source_0</value></param>
<param><key>address</key><value>"tcp://" + finalsplitip + ":" + finalsplitport</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>timeout</value></param>
</block>
<block>
<key>zeromq_push_sink</key>
<param><key>id</key><value>zeromq_push_sink_0_0</value></param>
<param><key>address</key><value>"tcp://" + ip + ":" + rxoutport</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>zrxrate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mintime</key><value>2000</value></param>
<param><key>alpha</key><value>0.15</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>ztxrate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mintime</key><value>2000</value></param>
<param><key>alpha</key><value>0.15</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>digital_burst_shaper_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_burst_shaper_xx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_burst_shaper_xx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>zeromq_push_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>zrxrate</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_0</source_block_id><sink_block_id>ztxrate</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
